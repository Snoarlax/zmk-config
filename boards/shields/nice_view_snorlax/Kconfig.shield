## boards/shields/nice_view_snorlax/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SNORLAX
    def_bool $(shields_list_contains,nice_view_snorlax)
```
